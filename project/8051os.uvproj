# Keil uVision project 8051os.uvproj, settings and files
target src (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 8051os +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\src\rtos
  group os
    ../src/rtos/: task.c cpuport.c
  group main
    ../src/: main.c
